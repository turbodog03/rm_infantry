# Keil uVision project rm_infantry.uvprojx, settings and files
target rm_infantry (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: rm_infantry +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --c99
  c include: ..\Inc;..\Inc\hal_inc;..\Inc\m3_inc;..\Inc\os_inc;..\Inc\hal_inc\Legacy;..\User;..\User\algorithm;..\User\app;..\User\driver
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group user_driver
    ../User/driver/: can_device.c uart_device.c calibrate.c keyboard.c
    ../User/: rm_hal_lib.h
  group user_algorithm
    ../User/algorithm/: pid.c ramp.c
    ./: crc16.c
  group user_app
    ../User/: startup.c startup.h
    ../User/app/: gimbal_task.c chassis_task.c detect_task.c shoot_task.c servo_task.c referee_usart_task.c referee_usart_task.h
  group user_custom
    ../User/app/: chassis_custom.c gimbal_custom.c shoot_custom.c
    ../User/: sys.h
  group lib_rm
    ../Inc/: rm_infantry1_2.lib stm32f4xx_it.c
  group user_doc
    ../Doc/: readme.txt
  group New Group
    ../User/referee/: bsp_usart.c CRC8_CRC16.c fifo.c struct_typedef.h referee.c protocol.h RM_Cilent_UI.c RM_Cilent_UI.h
